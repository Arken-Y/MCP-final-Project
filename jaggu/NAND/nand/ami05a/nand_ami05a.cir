* Component: /home/mentor/NAND/nand  Viewpoint: ami05a
.INCLUDE nand_ami05a.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
