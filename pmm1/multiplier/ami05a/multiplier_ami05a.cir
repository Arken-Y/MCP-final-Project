* Component: /home/mentor/pmm1/multiplier  Viewpoint: ami05a
.INCLUDE multiplier_ami05a.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
